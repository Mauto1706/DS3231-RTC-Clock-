# IAR project bappe.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: bappe.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c std_type.h
  group CLOCK
    ./: clock.c clock.h
  group Delay
    ./: delay.c delay.h
  group DS3231
    ./: DS3231.c DS3231.h
  group GPIO
    ./: gpio.c gpio.h
  group I2c
    ./: i2c_soft.c i2c_soft.h
  group I2c/cfg
    ./: i2c_soft_cfg.c i2c_soft_cfg.h
  group Sspi
    ./: sspi.c sspi.h
  group Sspi/spi_cfg
    ./: sspi_cfg.c sspi_cfg.h
